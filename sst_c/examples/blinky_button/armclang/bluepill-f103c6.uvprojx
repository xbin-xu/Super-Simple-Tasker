# Keil uVision project bluepill-f103c6.uvprojx, settings and files
target arm-bluepill-f103c6 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blinky_button
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103x6,SST_PORT_USE_LEGACY_BASEPRI=0,SST_TEST_PRIORITY_CEILING=0
  c include: .;..\..\..\..\include;..\..\..\ports\arm-cm;..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\3rd_party\bluepill-f103c6
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: blinky_button.h blinky1.c blinky3.c bsp.h bsp_bluepill-f103c6.c button2a.c button2b.c main.c
  group bluepill-f103c6
    ../../../../3rd_party/bluepill-f103c6/arm/: startup_stm32f103x6.s
    ../../../../3rd_party/bluepill-f103c6/: stm32f1xx.h system_stm32f1xx.c
  group sst
    ../../../src/: sst.c
  group sst_port
    ../../../ports/arm-cm/: sst_port.c sst_port.h
target case1-legacy=0 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: blinky_button
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103x6,SST_PORT_USE_LEGACY_BASEPRI=0,SST_TEST_PRIORITY_CEILING=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --entry Reset_Handler
target case2-legacy=1 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: blinky_button
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103x6,SST_PORT_USE_LEGACY_BASEPRI=1,SST_TEST_PRIORITY_CEILING=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --entry Reset_Handler
